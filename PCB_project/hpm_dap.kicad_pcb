# Repository KotoriProject/CherryDAP

## KiCad design PCB_project/hpm_dap.kicad_pcb

Parts:
D1: SR05; SOT-143
D2, D3: SRV05-4_TCT; SOT-23-6; MPN SRV05-4.TCT; Digi-Key_PN SRV05-4CT-ND
D4, D5: LED; LED_0603_1608Metric
F1: 200mA; Fuse_0603_1608Metric; LCSC C516070
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: 302-S101; 2x5P 2.54mm 夹贴; MPN 302-S101; Digi-Key_PN ED1543-ND
R6, R7: 5.1k; R_0402_1005Metric
R8, R9: 1kΩ; R_0402_1005Metric

Connections:
+3.3V: D2.5, D3.5, R9.1; also elsewhere on the board
/JTAG_TDI: D3.4, J2.2; also elsewhere on the board
/JTAG_TDO: D3.6, J2.6; also elsewhere on the board
/SWCLK/JTAG_TCK: D2.3, J2.3; also elsewhere on the board
/SWDIO/JTAG_TMS: D2.1, J2.5; also elsewhere on the board
/SWRST/JTAG_TRST: D2.6, J2.1; also elsewhere on the board
/TVCC: J2.9
/core/LED: R8.2; also elsewhere on the board
/core/USB_D+: D1.2 (L1), J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
/core/USB_D-: D1.3 (L2), J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
/uart_rx: D3.1, J2.8; also elsewhere on the board
/uart_tx: D3.3, J2.10; also elsewhere on the board
GND: D1.1 (VN), D2.2, D3.2, D4.1 (K), D5.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.7, R6.2, R7.2; also elsewhere on the board
unnamed: D4.2 (A), R9.2
unnamed: D5.2 (A), R8.1
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: J1.A5 (CC1), R6.1
unnamed: J1.B5 (CC2), R7.1
VBUS: D1.4 (VP), F1.2; also elsewhere on the board

Parts:
C19: 10uF; C_0402_1005Metric
C20: 430pF; C_0402_1005Metric
C21: 22uF; C_0402_1005Metric; LCSC C415703
R2: 309kΩ; R_0402_1005Metric
R3: 100kΩ; R_0402_1005Metric
U2: TPS82130; Texas_SIL0008D_MicroSiP-8-1EP_2.8x3mm_P0.65mm_EP1.1x1.9mm

Connections:
+3.3V: C21.1, R2.2, U2.4 (VOUT), U2.5 (VOUT); also elsewhere on the board
GND: C19.2, C20.2, C21.2, R3.1, U2.3 (GND), U2.9 (GND); also elsewhere on the board
unnamed: R2.1, R3.2, U2.6 (FB)
unnamed: C20.1, U2.8 (SS/TR)
VBUS: C19.1, U2.1 (EN), U2.2 (VIN); also elsewhere on the board

Parts:
C1, C3, C4, C5, C6, C7, C8, C12, C13, C15, C17, C22, C23, C24: 0.1uF; C_0402_1005Metric
C9: 1uF; C_0402_1005Metric
C10, C11: 22uF; C_0402_1005Metric
C14: 10uF; C_0402_1005Metric
C16, C18: 4.7uF; C_0402_1005Metric
L1: 120Ω@100MHZ; L_0402_1005Metric
L2: 4.7uH; L_Wuerth_MAPI-2510; LCSC C5832360
R1, R5: 10kΩ; R_0402_1005Metric
R4: 100kΩ; R_0402_1005Metric
R10, R11: 33Ω; R_0402_1005Metric
RN1, RN2: 22; R_Array_Concave_4x0402
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: HPM5301IEGx; QFN-48_6x6mm_P0.4mm_EP4.2x4.2mm
X1: 24MHz; CSTCE3213

Connections:
+3.3V: C13.1, C14.1, C22.2, C23.2, C24.2, L1.1, R1.2, SW1.1, U1.6 (VIO_B00), U1.16 (VPMC), U1.29 (VIO_B01), U1.34 (VIO_B00); also elsewhere on the board
/JTAG_TDI: RN2.5 (R4.2); also elsewhere on the board
/JTAG_TDO: RN2.6 (R3.2); also elsewhere on the board
/SWCLK/JTAG_TCK: RN1.7 (R2.2), RN2.7 (R2.2); also elsewhere on the board
/SWDIO/JTAG_TMS: RN1.6 (R3.2); also elsewhere on the board
/SWRST/JTAG_TRST: RN1.5 (R4.2); also elsewhere on the board
/core/BOOT0: R4.2, U1.8 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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)
/core/BOOT1: R5.2, U1.7 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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)
/core/LED: U1.48 (PA05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI0.S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); also elsewhere on the board
/core/SPI_CS: U1.25 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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), U1.42 (PA26/SPI1.CS0/XPI0.CA_D3/TRGM0.P02)
/core/USB_D+: U1.44 (PA24/I2C2.SCL/SPI1.CS2/XPI0.CA_CS1/TRGM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); also elsewhere on the board
/core/USB_D-: U1.43 (PA25/I2C2.SDA/SPI1.CS1/XPI0.CA_DQS/TRGM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); also elsewhere on the board
/core/Vana: C1.1, L1.2, U1.31 (VREFH), U1.32 (VANA)
/core/XTALI: U1.35 (XTALI), X1.1
/core/XTALO: U1.36 (XTALO), X1.3
/uart_rx: R11.1; also elsewhere on the board
/uart_tx: R10.1; also elsewhere on the board
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.2, C18.2, C22.1, C23.1, C24.1, R4.1, U1.30 (VREFL), U1.49 (VSS), X1.2; also elsewhere on the board
unnamed: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, L2.1, U1.5 (VDD_SOC), U1.9 (VDD_SOC), U1.28 (VDD_SOC), U1.33 (VDD_SOC), U1.45 (VDD_SOC)
unnamed: R5.1, SW1.2
unnamed: RN1.2 (R2.1), U1.41 (PA27/SPI1.SCLK/XPI0.CA_SCLK/TRGM0.P03)
unnamed: RN1.3 (R3.1), U1.39 (PA29/I2C3.SCL/SPI1.MOSI/XPI0.CA_D2/TRGM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)
unnamed: RN1.4 (R4.1), U1.37 (PA31/SPI1.DAT3/XPI0.CA_CS0/TRGM0.P07/US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)
unnamed: RN2.2 (R2.1), U1.24 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/ADC0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)
unnamed: RN2.3 (R3.1), U1.23 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/TRGM0.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)
unnamed: RN2.4 (R4.1), U1.22 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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)
unnamed: L2.2, U1.15 (DCDC_LP)
unnamed: C12.1, R1.1, U1.13 (RESETN)
unnamed: C17.1, C18.1, U1.10 (VDD_OTPCAP)
unnamed: C15.2, C16.2, U1.17 (VDD_PMCCAP)
unnamed: R10.2, U1.12 (PA00/TMR1.COMP0/URT0.TXD/TRGM0.P00)
unnamed: R11.2, U1.11 (PA01/TMR1.CAPT0/URT0.RXD/TRGM0.P01/ACMP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)

Notes on the sheet:
注意：本产品的 LQFP64、QFN48 封装上： ● USB_DP 与 PA24 复用，当用作 USB 功能时，应当配置 PA24 为模拟功能（PAD[FUNC_CTL].ANALOG 位置 1） ● USB_DM 与 PA25 复用，当用作 USB 功能时，应当配置 PA25 为模拟功能（PAD[FUNC_CTL].ANALOG 位置 1） ● 在系统编程（ISP）模式下，仅支持从 UART0 烧写固件，或从 UART0 启动

Board: 2 copper layers, 28.0 x 17.0 mm, 50 parts (17 on the bottom side), 40 nets.

## Commit log

2024-06-25 添加PCB_project
2024-06-27 PCB layout 完毕
2024-06-30 添加钢网文件
2024-06-30 vscode push test
2024-06-30 tortoise push test
2024-07-01 原理图错误，HPM5301的VDD_SOC引脚应当连接到内部DCDC_LP(输出)，不应当连接到3.3V供电
2024-07-01 token push test
2024-07-01 小乌龟测试
2024-07-01 push test
2024-10-11 Initial gh-pages commit
2024-10-11 Deploying to gh-pages from @ KotoriProject/CherryDAP@19922dbcd180572563aa053cfb98bc6fb79b1c33 🚀
2024-10-11 屏蔽log输出
2024-10-11 更改usb串口到uart0
